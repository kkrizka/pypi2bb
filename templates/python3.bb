inherit setuptools3
require python-{{package}}.inc
